# IAR project RFTemperaturHumiditySensor.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; Sensors/DHT22; Sensors/PPD42NS; CC2530Generic; CC253x; IEEE_802.15.4
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: Config.h dht22_cfg.h gp2y1050.h_cfg.h main.c RFTemperatureHumiditySensor.h
  group CC2530Generic
    CC2530Generic/: board.c board.h
  group CC253x
    CC253x/: ADC.c ADC.h CC253x.c CC253x.h PlatformTypes.h Timer1.c Timer1.h
  group IEEE_802.15.4
    IEEE_802.15.4/: IEEE_802.15.4.c IEEE_802.15.4.h
  group Sensors/DHT22
    Sensors/DHT22/: dht22.c dht22.h
  group Sensors/GP2Y1050
    Sensors/GP2Y1050/: gp2y1050.c gp2y1050.h
  group Sensors/PPD42NS
    Sensors/PPD42NS/: ppd42ns.c ppd42ns.h
